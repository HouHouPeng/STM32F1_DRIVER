# Keil uVision project SusuperP.uvprojx, settings and files
target SusuperP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SusuperP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\Project;..\STM32F10x_FWLib\inc;..\System;..\User;..\Project\BEEP;..\Project\LED;..\System\sys;..\System\delay;..\System\usart;..\Project\ADC;..\Project\DAC;..\Project\KEY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s
  group Project
    ../Project/BEEP/: beep.c
    ../Project/LED/: led.c
    ../Project/ADC/: adc.c
    ../Project/DAC/: dac.c
    ../Project/KEY/: key.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../System/delay/: delay.c
    ../System/usart/: usart.c
    ../System/sys/: sys.c
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
